options:
  parameters:
    generate_options: qt_gui
    id: pluto01
    output_language: python
    title: Application note TBR-1-6
  states: {}

blocks:
- name: decim_xlate
  id: variable
  parameters:
    value: '18'
  states: {}
- name: decim_xlate_if
  id: variable
  parameters:
    value: '64'
  states: {}
- name: if_tune_fq
  id: variable_qtgui_range
  parameters:
    label: Tune FQ
    start: '500'
    step: '1'
    stop: '1500'
    value: '985'
  states: {}
- name: pll_det_half_bw
  id: variable
  parameters:
    value: '100'
  states: {}
- name: rx_tune_fq
  id: variable
  parameters:
    value: 11703504000-9750000000
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: samp_rate_low
  id: variable
  parameters:
    value: samp_rate_mid/decim_xlate_if
  states: {}
- name: samp_rate_mid
  id: variable
  parameters:
    value: samp_rate/decim_xlate
  states: {}
- name: xlate_taps1
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '3000'
    low_cutoff_freq: '200'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: xlate_taps2
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '100'
    gain: '100'
    samp_rate: samp_rate_mid
    width: '30'
    win: window.WIN_HAMMING
  states: {}
- name: analog_pll_freqdet_cf_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: pll_det_half_bw*2*3.14/samp_rate_low
    min_freq: '-pll_det_half_bw*2*3.14/samp_rate_low'
    w: 3.14/1000
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: if_tune_fq
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: 1x.bin
    type: float
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '500'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate_low/2/3.14
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: decim_xlate
    samp_rate: samp_rate
    taps: xlate_taps1
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: if_tune_fq
    decim: decim_xlate_if
    samp_rate: samp_rate_mid
    taps: xlate_taps2
    type: ccc
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: rx_tune_fq
    gain1: '''fast_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: pll_det_half_bw
    min: '-pll_det_half_bw'
    name: PLL output
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    max: '10'
    min: '-10'
    name: Audio FQ
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_mid
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_mid/decim_xlate_if
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}

connections:
- [analog_pll_freqdet_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_complex_to_real_0, '0', audio_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_number_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_real_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_pll_freqdet_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_sink_x_0_0, '0']
- [iio_pluto_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
